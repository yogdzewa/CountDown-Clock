# Keil uVision project STC_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC_DemoV35a +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./source/: main.c STCBSP_V3.5a.LIB init.c display_decode.c internal_callback.c callback.h user_callback.c help_func.c help_func.h main_loop.c main_loop.h
    ./: STARTUP.A51
